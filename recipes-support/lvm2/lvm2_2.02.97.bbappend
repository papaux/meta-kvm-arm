FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Corrects-the-use-of-a-deprecated-typedef.patch \
	    "

